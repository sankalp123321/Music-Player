# Keil uVision project LPC1768_FatFs.uvprojx, settings and files
target MCB1768_RAM (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LPC1700_FatFs
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: .\FatFs;.\LPC1700\Core_CM3;.\LPC1700\UART;.\LPC1700\RTC;.\LPC1700\Utility
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group LPC1768
    ./LPC1700/Core_CM3/: system_LPC17xx.c startup_LPC17xx.s
    ./LPC1700/SPI_SD/: LPC17xx_spi.c LPC17xx_sd.c
    ./LPC1700/UART/: lpc17xx_uart.c
    ./LPC1700/RTC/: lpc17xx_rtc.c
    ./LPC1700/Utility/: monitor.c
  group FatFs
    ./FatFs/: ff.c
    ./FatFs/option/: ccsbcs.c
  group Main
    ./Main/: main.c
    ./: delay.c uart.c List.c List.h
target MCB1768_Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: as above
  output: LPC1700_FatFs +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.1.2
